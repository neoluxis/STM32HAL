# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\HARDWARE;.\SYSTEM;.\STM32F10x_FWLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: mian.c core_cm3.c
  group HARDWARE
    ./HARDWARE/: exti.c key.c led.c pwm.c timer.c wdg.c
  group SYSTEM
    ./SYSTEM/: delay.c sys.c usart.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
