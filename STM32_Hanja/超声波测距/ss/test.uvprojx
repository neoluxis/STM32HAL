# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\HARDWARE\GUI;.\HARDWARE\LCD;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\STM32F10x_FWLib\inc;.\CORE;.\HARDWARE\24CXX;.\HARDWARE\FLASH;.\HARDWARE\IIC;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\PWM;.\HARDWARE\TIMER;.\HARDWARE\TOUCH;..\ss
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: mian.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c
  group Core
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
